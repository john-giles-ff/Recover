# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ../../gui/include; ..\..\target\include; ..\..\platform\os; ../../generated/fonts/include; ../../generated/images/include; ../../generated/texts/include; ../../generated/gui_generated/include; ../../touchgfx/framework/include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\Components; ..\bsp\source\vendor\ETEM070001ZDH6; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7; ../../generated/videos/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ../../touchgfx/lib/core/cortex_m7/IAR8.x/touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_consola_150_2bpp_0.cpp Font_consola_20_1bpp_0.cpp Font_consola_20_1bpp_4.cpp Font_consola_20_2bpp_0.cpp Font_consola_20_2bpp_4.cpp Font_segoeuisl_20_2bpp_0.cpp Font_segoeuisl_20_2bpp_4.cpp Font_segoeuisl_24_2bpp_0.cpp Font_segoeuisl_24_2bpp_31.cpp Font_segoeuisl_24_2bpp_4.cpp Font_segoeuisl_38_2bpp_0.cpp Font_segoeuisl_42_2bpp_0.cpp Font_segoeuisl_55_4bpp_0.cpp Font_segoeuisl_55_4bpp_4.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_0.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_10.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_11.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_12.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_13.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_14.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_15.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_16.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_17.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_18.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_19.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_31.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_6.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp_9.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_0.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_10.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_11.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_12.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_13.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_14.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_15.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_16.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_17.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_18.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_19.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_31.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_4.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_6.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp_9.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_0.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_10.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_11.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_12.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_13.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_14.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_15.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_16.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_17.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_18.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_19.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp_9.cpp FontCache.cpp GeneratedFont.cpp Kerning_consola_150_2bpp.cpp Kerning_consola_20_1bpp.cpp Kerning_consola_20_2bpp.cpp Kerning_segoeuisl_20_2bpp.cpp Kerning_segoeuisl_24_2bpp.cpp Kerning_segoeuisl_38_2bpp.cpp Kerning_segoeuisl_42_2bpp.cpp Kerning_segoeuisl_55_4bpp.cpp Kerning_SourceHanSerifSC_Light_otf_20_2bpp.cpp Kerning_SourceHanSerifSC_Light_otf_24_2bpp.cpp Kerning_SourceHanSerifSC_Light_otf_55_2bpp.cpp Table_consola_150_2bpp.cpp Table_consola_20_1bpp.cpp Table_consola_20_2bpp.cpp Table_segoeuisl_20_2bpp.cpp Table_segoeuisl_24_2bpp.cpp Table_segoeuisl_38_2bpp.cpp Table_segoeuisl_42_2bpp.cpp Table_segoeuisl_55_4bpp.cpp Table_SourceHanSerifSC_Light_otf_20_2bpp.cpp Table_SourceHanSerifSC_Light_otf_24_2bpp.cpp Table_SourceHanSerifSC_Light_otf_55_2bpp.cpp UnmappedDataFont.cpp
  group Application/generated/gui_generated/auditscreen_screen
    ../../generated/gui_generated/src/auditscreen_screen/: AuditScreenViewBase.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: AbortingWindowBase.cpp AuditLogBase.cpp BackgroundBase.cpp DatePickerBase.cpp DeadSpaceAnimationBase.cpp EngineerOverlayBase.cpp ErrorBoxBase.cpp ExternalSwitchErrorWindowBase.cpp FilterStateMessageBase.cpp InternalSwitchErrorBase.cpp KeypadBase.cpp LogsExportingBase.cpp MoistureDetectedMessageBase.cpp MsgBoxBase.cpp TabBase.cpp TouchTestBase.cpp UsageInstructionsBase.cpp ViewDiagnosticsBase.cpp
  group Application/generated/gui_generated/eggscreen_screen
    ../../generated/gui_generated/src/eggscreen_screen/: EggScreenViewBase.cpp
  group Application/generated/gui_generated/freda_screen
    ../../generated/gui_generated/src/freda_screen/: FREDAViewBase.cpp
  group Application/generated/gui_generated/graphscreen_screen
    ../../generated/gui_generated/src/graphscreen_screen/: GraphScreenViewBase.cpp
  group Application/generated/gui_generated/idlescreen_screen
    ../../generated/gui_generated/src/idlescreen_screen/: IdleScreenViewBase.cpp
  group Application/generated/gui_generated/mainscreen_screen
    ../../generated/gui_generated/src/mainscreen_screen/: MainScreenViewBase.cpp
  group Application/generated/gui_generated/powerlossrecoveryscreen_screen
    ../../generated/gui_generated/src/powerlossrecoveryscreen_screen/: PowerlossRecoveryScreenViewBase.cpp
  group Application/generated/gui_generated/processscreen_screen
    ../../generated/gui_generated/src/processscreen_screen/: ProcessScreenViewBase.cpp
  group Application/generated/gui_generated/settingsscreen_screen
    ../../generated/gui_generated/src/settingsscreen_screen/: SettingsScreenViewBase.cpp
  group Application/generated/gui_generated/touchtestscreen_screen
    ../../generated/gui_generated/src/touchtestscreen_screen/: TouchTestScreenViewBase.cpp
  group Application/generated/gui_generated/usbmode_screen
    ../../generated/gui_generated/src/usbmode_screen/: UsbModeViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: BitmapDatabase.cpp image_abort.cpp image_AnimationBackground.cpp image_Audit-log.cpp image_back.cpp image_Button.cpp image_Button_pressed.cpp image_Button_Red.cpp image_Check_checked.cpp image_Check_unchecked.cpp image_ClockIcon.cpp image_Complete.cpp image_Copper.cpp image_DefaultIdleIcon.cpp image_Down.cpp image_ErrorButton.cpp image_ErrorIcon.cpp image_Failed.cpp image_FF_Logo.cpp image_Finger_tap.cpp image_finger_vertical_swipe.cpp image_Information.cpp image_LargeChamber.cpp image_maximise.cpp image_MessageBackground.cpp image_Minimise.cpp image_Next.cpp image_power.cpp image_Previous.cpp image_progressbackground_320x40.cpp image_RECOVER_empty_splash.cpp image_Recover_Logo.cpp image_RECOVER_splash.cpp image_ScreenOffIdleIcon.cpp image_Settings.cpp image_Silver.cpp image_SmallChamber.cpp image_start.cpp image_start_disabled.cpp image_TipIcon.cpp image_trash.cpp image_trash_clicked.cpp image_Up.cpp image_USB_Icon.cpp image_wide_slider_handle.cpp image_X.cpp
  group Application/generated/images/FumeAnimation
    ../../generated/images/src/FumeAnimation/: image_Fume0000.cpp image_Fume0001.cpp image_Fume0002.cpp image_Fume0003.cpp image_Fume0004.cpp image_Fume0005.cpp image_Fume0006.cpp image_Fume0007.cpp image_Fume0008.cpp image_Fume0009.cpp image_Fume0010.cpp image_Fume0011.cpp image_Fume0012.cpp image_Fume0013.cpp image_Fume0014.cpp image_Fume0015.cpp image_Fume0016.cpp image_Fume0017.cpp image_Fume0018.cpp image_Fume0019.cpp image_Fume0020.cpp image_Fume0021.cpp image_Fume0022.cpp image_Fume0023.cpp image_Fume0024.cpp image_Fume0025.cpp image_Fume0026.cpp image_Fume0027.cpp image_Fume0028.cpp image_Fume0029.cpp image_Fume0030.cpp image_Fume0031.cpp image_Fume0032.cpp image_Fume0033.cpp image_Fume0034.cpp image_Fume0035.cpp image_Fume0036.cpp image_Fume0037.cpp image_Fume0038.cpp image_Fume0039.cpp image_Fume0040.cpp image_Fume0041.cpp image_Fume0042.cpp image_Fume0043.cpp image_Fume0044.cpp image_Fume0045.cpp image_Fume0046.cpp image_Fume0047.cpp image_Fume0048.cpp image_Fume0049.cpp image_Fume0050.cpp image_Fume0051.cpp image_Fume0052.cpp image_Fume0053.cpp image_Fume0054.cpp image_Fume0055.cpp image_Fume0056.cpp image_Fume0057.cpp image_Fume0058.cpp image_Fume0059.cpp image_Fume0060.cpp image_Fume0061.cpp image_Fume0062.cpp image_Fume0063.cpp image_Fume0064.cpp image_Fume0065.cpp image_Fume0066.cpp image_Fume0067.cpp image_Fume0068.cpp image_Fume0069.cpp image_Fume0070.cpp image_Fume0071.cpp image_Fume0072.cpp image_Fume0073.cpp image_Fume0074.cpp image_Fume0075.cpp image_Fume0076.cpp image_Fume0077.cpp image_Fume0078.cpp image_Fume0079.cpp image_Fume0080.cpp image_Fume0081.cpp image_Fume0082.cpp image_Fume0083.cpp image_Fume0084.cpp image_Fume0085.cpp image_Fume0086.cpp image_Fume0087.cpp image_Fume0088.cpp image_Fume0089.cpp image_Fume0090.cpp image_Fume0091.cpp image_Fume0092.cpp image_Fume0093.cpp image_Fume0094.cpp image_Fume0095.cpp image_Fume0096.cpp image_Fume0097.cpp image_Fume0098.cpp image_Fume0099.cpp image_Fume0100.cpp image_Fume0101.cpp image_Fume0102.cpp image_Fume0103.cpp
  group Application/generated/images/InitialiseAnimation
    ../../generated/images/src/InitialiseAnimation/: image_Initialise0000.cpp image_Initialise0001.cpp image_Initialise0002.cpp image_Initialise0003.cpp image_Initialise0004.cpp image_Initialise0005.cpp image_Initialise0006.cpp image_Initialise0007.cpp image_Initialise0008.cpp image_Initialise0009.cpp image_Initialise0010.cpp image_Initialise0011.cpp image_Initialise0012.cpp image_Initialise0013.cpp image_Initialise0014.cpp image_Initialise0015.cpp image_Initialise0016.cpp image_Initialise0017.cpp image_Initialise0018.cpp image_Initialise0019.cpp
  group Application/generated/images/Instructions
    ../../generated/images/src/Instructions/: image_Instruction_AddGlass.cpp image_Instruction_LidClosed.cpp image_Instruction_Precursor.cpp image_Instruction_Sample.cpp image_Instruction_SelectChamber.cpp image_Instruction_SelectMetal.cpp image_Instruction_StartButton.cpp
  group Application/generated/images/Keyboard
    ../../generated/images/src/Keyboard/: image_keyboard_background.cpp image_keyboard_key_delete_highlighted.cpp image_keyboard_key_enter_highlighted.cpp image_keyboard_key_highlighted.cpp image_keyboard_key_num_highlighted.cpp image_keyboard_key_shift_highlighted.cpp image_keyboard_space_highlighted.cpp
  group Application/generated/images/PatternLock
    ../../generated/images/src/PatternLock/: image_PatternBackground.cpp image_Point.cpp image_Point_selected.cpp
  group Application/generated/images/PumpAnimation
    ../../generated/images/src/PumpAnimation/: image_Pump0000.cpp image_Pump0001.cpp image_Pump0002.cpp image_Pump0003.cpp image_Pump0004.cpp image_Pump0005.cpp image_Pump0006.cpp image_Pump0007.cpp image_Pump0008.cpp image_Pump0009.cpp image_Pump0010.cpp image_Pump0011.cpp image_Pump0012.cpp image_Pump0013.cpp image_Pump0014.cpp image_Pump0015.cpp image_Pump0016.cpp image_Pump0017.cpp image_Pump0018.cpp image_Pump0019.cpp
  group Application/generated/images/SliderAnimation
    ../../generated/images/src/SliderAnimation/: image_SliderAnimation.0000.cpp image_SliderAnimation.0002.cpp image_SliderAnimation.0004.cpp image_SliderAnimation.0006.cpp image_SliderAnimation.0008.cpp image_SliderAnimation.0010.cpp image_SliderAnimation.0012.cpp image_SliderAnimation.0014.cpp image_SliderAnimation.0016.cpp image_SliderAnimation.0018.cpp image_SliderAnimation.0020.cpp image_SliderAnimation.0022.cpp image_SliderAnimation.0024.cpp
  group Application/generated/images/States
    ../../generated/images/src/States/: image_fan_bad.cpp image_filter_bad.cpp image_filter_good.cpp image_filter_medium.cpp image_LowPressureIcon.cpp image_water.cpp
  group Application/generated/images/Transparent
    ../../generated/images/src/Transparent/: image_Transparent.cpp image_Transparent_125x250.cpp image_Transparent_250x250.cpp
  group Application/generated/images/TuningAnimation
    ../../generated/images/src/TuningAnimation/: image_Tuning0000.cpp image_Tuning0001.cpp image_Tuning0002.cpp image_Tuning0003.cpp image_Tuning0004.cpp image_Tuning0005.cpp image_Tuning0006.cpp image_Tuning0007.cpp image_Tuning0008.cpp image_Tuning0009.cpp image_Tuning0010.cpp image_Tuning0011.cpp image_Tuning0012.cpp image_Tuning0013.cpp image_Tuning0014.cpp image_Tuning0015.cpp image_Tuning0016.cpp image_Tuning0017.cpp image_Tuning0018.cpp image_Tuning0019.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageAr.cpp LanguageDe.cpp LanguageEs.cpp LanguageFr.cpp LanguageGb.cpp LanguageIt.cpp LanguagePl.cpp LanguagePt.cpp LanguageRu.cpp LanguageUa.cpp LanguageZhs.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/auditscreen_screen
    ../../gui/src/auditscreen_screen/: AuditScreenPresenter.cpp AuditScreenView.cpp
  group Application/gui/common
    ../../gui/src/common/: CustomKeyboard.cpp date.cpp FrontendApplication.cpp Lever.cpp LFTDebug.cpp PatternCode.cpp Pong.cpp ProductionTestStep.cpp ProgressBar.cpp String.cpp TextRadioButton.cpp Unlock.cpp
  group Application/gui/common/graph_widget
    ../../gui/src/common/graph_widget/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterVerticalAlpha.cpp
  group Application/gui/containers
    ../../gui/src/containers/: AbortingWindow.cpp AuditLog.cpp Background.cpp DatePicker.cpp DeadSpaceAnimation.cpp EngineerOverlay.cpp ErrorBox.cpp ExternalSwitchErrorWindow.cpp FilterStateMessage.cpp InternalSwitchError.cpp Keypad.cpp LogsExporting.cpp MoistureDetectedMessage.cpp MsgBox.cpp Tab.cpp TouchTest.cpp UsageInstructions.cpp ViewDiagnostics.cpp
  group Application/gui/eggscreen_screen
    ../../gui/src/eggscreen_screen/: EggScreenPresenter.cpp EggScreenView.cpp
  group Application/gui/freda_screen
    ../../gui/src/freda_screen/: FREDAPresenter.cpp FREDAView.cpp
  group Application/gui/graphscreen_screen
    ../../gui/src/graphscreen_screen/: GraphScreenPresenter.cpp GraphScreenView.cpp
  group Application/gui/idlescreen_screen
    ../../gui/src/idlescreen_screen/: IdleScreenPresenter.cpp IdleScreenView.cpp
  group Application/gui/LFT
    ../../gui/src/LFT/: LFT.cpp LFT_Auto.cpp LFT_AutoClean.cpp LFT_Information.cpp LFT_Logs.cpp LFT_Manual.cpp LFT_ProductionTests.cpp LFT_Settings.cpp
  group Application/gui/LFT/Definitions
    ../../gui/src/LFT/Definitions/: ProgressStages.cpp
  group Application/gui/mainscreen_screen
    ../../gui/src/mainscreen_screen/: MainScreenPresenter.cpp MainScreenView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/powerlossrecoveryscreen_screen
    ../../gui/src/powerlossrecoveryscreen_screen/: PowerlossRecoveryScreenPresenter.cpp PowerlossRecoveryScreenView.cpp
  group Application/gui/processscreen_screen
    ../../gui/src/processscreen_screen/: ProcessScreenPresenter.cpp ProcessScreenView.cpp
  group Application/gui/settingsscreen_screen
    ../../gui/src/settingsscreen_screen/: SettingsScreenPresenter.cpp SettingsScreenView.cpp
  group Application/gui/touchtestscreen_screen
    ../../gui/src/touchtestscreen_screen/: TouchTestScreenPresenter.cpp TouchTestScreenView.cpp
  group Application/gui/usbmode_screen
    ../../gui/src/usbmode_screen/: UsbModePresenter.cpp UsbModeView.cpp
  group Application/main
    ../: main.cpp
  group Board/ETEM070001ZDH6
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/ETEM070001ZDH6/BSP
    ../bsp/source/bsp/: ETEM070001ZDH6TouchController.cpp STM32F7Instrumentation.cpp
  group Board/ETEM070001ZDH6/Vendor
    ../bsp/source/vendor/ETEM070001ZDH6/: etem070001zdh6.c etem070001zdh6_lcd.c etem070001zdh6_qspi.c etem070001zdh6_sdram.c etem070001zdh6_ts.c
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
