# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\gui\include; ..\..\target\include; ..\..\platform\os; ..\..\generated\fonts\include; ..\..\generated\images\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\Components; ..\bsp\source\vendor\ETEM070001ZDH6; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m7\IAR8.x\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp Font_consola_150_2bpp.cpp Font_consola_20_1bpp.cpp Font_consola_20_2bpp.cpp Font_segoeuisl_20_2bpp.cpp Font_segoeuisl_24_2bpp.cpp Font_segoeuisl_38_2bpp.cpp Font_segoeuisl_42_2bpp.cpp Font_segoeuisl_55_4bpp.cpp Font_SourceHanSerifSC_Light_otf_20_2bpp.cpp Font_SourceHanSerifSC_Light_otf_24_2bpp.cpp Font_SourceHanSerifSC_Light_otf_55_2bpp.cpp FontGetters.cpp Kerning_consola_150_2bpp.cpp Kerning_consola_20_1bpp.cpp Kerning_consola_20_2bpp.cpp Kerning_segoeuisl_20_2bpp.cpp Kerning_segoeuisl_24_2bpp.cpp Kerning_segoeuisl_38_2bpp.cpp Kerning_segoeuisl_42_2bpp.cpp Kerning_segoeuisl_55_4bpp.cpp Kerning_SourceHanSerifSC_Light_otf_20_2bpp.cpp Kerning_SourceHanSerifSC_Light_otf_24_2bpp.cpp Kerning_SourceHanSerifSC_Light_otf_55_2bpp.cpp Table_consola_150_2bpp.cpp Table_consola_20_1bpp.cpp Table_consola_20_2bpp.cpp Table_segoeuisl_20_2bpp.cpp Table_segoeuisl_24_2bpp.cpp Table_segoeuisl_38_2bpp.cpp Table_segoeuisl_42_2bpp.cpp Table_segoeuisl_55_4bpp.cpp Table_SourceHanSerifSC_Light_otf_20_2bpp.cpp Table_SourceHanSerifSC_Light_otf_24_2bpp.cpp Table_SourceHanSerifSC_Light_otf_55_2bpp.cpp
  group Application/generated/gui_generated/auditscreen_screen
    ../../generated/gui_generated/src/auditscreen_screen/: AuditScreenViewBase.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: AbortingWindowBase.cpp AuditLogBase.cpp BackgroundBase.cpp DatePickerBase.cpp DeadSpaceAnimationBase.cpp EngineerOverlayBase.cpp ErrorBoxBase.cpp ExternalSwitchErrorWindowBase.cpp FilterStateMessageBase.cpp InternalSwitchErrorBase.cpp KeypadBase.cpp LogsExportingBase.cpp LowPressureMessageBase.cpp MsgBoxBase.cpp TabBase.cpp TouchTestBase.cpp UsageInstructionsBase.cpp
  group Application/generated/gui_generated/eggscreen_screen
    ../../generated/gui_generated/src/eggscreen_screen/: EggScreenViewBase.cpp
  group Application/generated/gui_generated/freda_screen
    ../../generated/gui_generated/src/freda_screen/: FREDAViewBase.cpp
  group Application/generated/gui_generated/graphscreen_screen
    ../../generated/gui_generated/src/graphscreen_screen/: GraphScreenViewBase.cpp
  group Application/generated/gui_generated/idlescreen_screen
    ../../generated/gui_generated/src/idlescreen_screen/: IdleScreenViewBase.cpp
  group Application/generated/gui_generated/mainscreen_screen
    ../../generated/gui_generated/src/mainscreen_screen/: MainScreenViewBase.cpp
  group Application/generated/gui_generated/powerlossrecoveryscreen_screen
    ../../generated/gui_generated/src/powerlossrecoveryscreen_screen/: PowerlossRecoveryScreenViewBase.cpp
  group Application/generated/gui_generated/processscreen_screen
    ../../generated/gui_generated/src/processscreen_screen/: ProcessScreenViewBase.cpp
  group Application/generated/gui_generated/settingsscreen_screen
    ../../generated/gui_generated/src/settingsscreen_screen/: SettingsScreenViewBase.cpp
  group Application/generated/gui_generated/touchtestscreen_screen
    ../../generated/gui_generated/src/touchtestscreen_screen/: TouchTestScreenViewBase.cpp
  group Application/generated/gui_generated/usbmode_screen
    ../../generated/gui_generated/src/usbmode_screen/: UsbModeViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: abort.cpp AnimationBackground.cpp Audit-log.cpp back.cpp BitmapDatabase.cpp Button.cpp Button_pressed.cpp Button_Red.cpp Check_checked.cpp Check_unchecked.cpp ClockIcon.cpp Complete.cpp Copper.cpp DefaultIdleIcon.cpp Down.cpp ErrorButton.cpp ErrorIcon.cpp expand.cpp Failed.cpp FF_Logo.cpp Finger_tap.cpp finger_vertical_swipe.cpp Information.cpp LargeChamber.cpp MessageBackground.cpp Minimise.cpp Next.cpp power.cpp Previous.cpp RECOVER_empty_splash.cpp Recover_Logo.cpp RECOVER_splash.cpp ScreenOffIdleIcon.cpp Settings.cpp Silver.cpp SmallChamber.cpp start.cpp start_disabled.cpp TipIcon.cpp trash.cpp trash_clicked.cpp Up.cpp USB_Icon.cpp wide_slider_handle.cpp X.cpp
  group Application/generated/images/FumeAnimation
    ../../generated/images/src/FumeAnimation/: Fume0000.cpp Fume0001.cpp Fume0002.cpp Fume0003.cpp Fume0004.cpp Fume0005.cpp Fume0006.cpp Fume0007.cpp Fume0008.cpp Fume0009.cpp Fume0010.cpp Fume0011.cpp Fume0012.cpp Fume0013.cpp Fume0014.cpp Fume0015.cpp Fume0016.cpp Fume0017.cpp Fume0018.cpp Fume0019.cpp Fume0020.cpp Fume0021.cpp Fume0022.cpp Fume0023.cpp Fume0024.cpp Fume0025.cpp Fume0026.cpp Fume0027.cpp Fume0028.cpp Fume0029.cpp Fume0030.cpp Fume0031.cpp Fume0032.cpp Fume0033.cpp Fume0034.cpp Fume0035.cpp Fume0036.cpp Fume0037.cpp Fume0038.cpp Fume0039.cpp Fume0040.cpp Fume0041.cpp Fume0042.cpp Fume0043.cpp Fume0044.cpp Fume0045.cpp Fume0046.cpp Fume0047.cpp Fume0048.cpp Fume0049.cpp Fume0050.cpp Fume0051.cpp Fume0052.cpp Fume0053.cpp Fume0054.cpp Fume0055.cpp Fume0056.cpp Fume0057.cpp Fume0058.cpp Fume0059.cpp Fume0060.cpp Fume0061.cpp Fume0062.cpp Fume0063.cpp Fume0064.cpp Fume0065.cpp Fume0066.cpp Fume0067.cpp Fume0068.cpp Fume0069.cpp Fume0070.cpp Fume0071.cpp Fume0072.cpp Fume0073.cpp Fume0074.cpp Fume0075.cpp Fume0076.cpp Fume0077.cpp Fume0078.cpp Fume0079.cpp Fume0080.cpp Fume0081.cpp Fume0082.cpp Fume0083.cpp Fume0084.cpp Fume0085.cpp Fume0086.cpp Fume0087.cpp Fume0088.cpp Fume0089.cpp Fume0090.cpp Fume0091.cpp Fume0092.cpp Fume0093.cpp Fume0094.cpp Fume0095.cpp Fume0096.cpp Fume0097.cpp Fume0098.cpp Fume0099.cpp Fume0100.cpp Fume0101.cpp Fume0102.cpp Fume0103.cpp
  group Application/generated/images/InitialiseAnimation
    ../../generated/images/src/InitialiseAnimation/: Initialise0000.cpp Initialise0001.cpp Initialise0002.cpp Initialise0003.cpp Initialise0004.cpp Initialise0005.cpp Initialise0006.cpp Initialise0007.cpp Initialise0008.cpp Initialise0009.cpp Initialise0010.cpp Initialise0011.cpp Initialise0012.cpp Initialise0013.cpp Initialise0014.cpp Initialise0015.cpp Initialise0016.cpp Initialise0017.cpp Initialise0018.cpp Initialise0019.cpp
  group Application/generated/images/Instructions
    ../../generated/images/src/Instructions/: Instruction_AddGlass.cpp Instruction_LidClosed.cpp Instruction_Precursor.cpp Instruction_Sample.cpp Instruction_SelectChamber.cpp Instruction_SelectMetal.cpp Instruction_StartButton.cpp
  group Application/generated/images/Keyboard
    ../../generated/images/src/Keyboard/: keyboard_background.cpp keyboard_key_delete_highlighted.cpp keyboard_key_enter_highlighted.cpp keyboard_key_highlighted.cpp keyboard_key_num_highlighted.cpp keyboard_key_shift_highlighted.cpp keyboard_space_highlighted.cpp
  group Application/generated/images/PatternLock
    ../../generated/images/src/PatternLock/: PatternBackground.cpp Point.cpp Point_selected.cpp
  group Application/generated/images/PumpAnimation
    ../../generated/images/src/PumpAnimation/: Pump0000.cpp Pump0001.cpp Pump0002.cpp Pump0003.cpp Pump0004.cpp Pump0005.cpp Pump0006.cpp Pump0007.cpp Pump0008.cpp Pump0009.cpp Pump0010.cpp Pump0011.cpp Pump0012.cpp Pump0013.cpp Pump0014.cpp Pump0015.cpp Pump0016.cpp Pump0017.cpp Pump0018.cpp Pump0019.cpp
  group Application/generated/images/SliderAnimation
    ../../generated/images/src/SliderAnimation/: SliderAnimation.0000.cpp SliderAnimation.0002.cpp SliderAnimation.0004.cpp SliderAnimation.0006.cpp SliderAnimation.0008.cpp SliderAnimation.0010.cpp SliderAnimation.0012.cpp SliderAnimation.0014.cpp SliderAnimation.0016.cpp SliderAnimation.0018.cpp SliderAnimation.0020.cpp SliderAnimation.0022.cpp SliderAnimation.0024.cpp
  group Application/generated/images/States
    ../../generated/images/src/States/: fan_bad.cpp filter_bad.cpp filter_good.cpp filter_medium.cpp LowPressureIcon.cpp
  group Application/generated/images/Transparent
    ../../generated/images/src/Transparent/: Transparent.cpp Transparent_125x250.cpp Transparent_250x250.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageDe.cpp LanguageEs.cpp LanguageFr.cpp LanguageGb.cpp LanguageIt.cpp LanguagePt.cpp LanguageRu.cpp LanguageZhs.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/auditscreen_screen
    ../../gui/src/auditscreen_screen/: AuditScreenPresenter.cpp AuditScreenView.cpp
  group Application/gui/common
    ../../gui/src/common/: CustomKeyboard.cpp date.cpp FrontendApplication.cpp Lever.cpp LFTDebug.cpp PatternCode.cpp Pong.cpp ProductionTestStep.cpp ProgressBar.cpp String.cpp TextRadioButton.cpp Unlock.cpp
  group Application/gui/common/graph_widget
    ../../gui/src/common/graph_widget/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterVerticalAlpha.cpp
  group Application/gui/containers
    ../../gui/src/containers/: AbortingWindow.cpp AuditLog.cpp Background.cpp DatePicker.cpp DeadSpaceAnimation.cpp EngineerOverlay.cpp ErrorBox.cpp ExternalSwitchErrorWindow.cpp FilterStateMessage.cpp InternalSwitchError.cpp Keypad.cpp LogsExporting.cpp LowPressureMessage.cpp MsgBox.cpp Tab.cpp TouchTest.cpp UsageInstructions.cpp
  group Application/gui/eggscreen_screen
    ../../gui/src/eggscreen_screen/: EggScreenPresenter.cpp EggScreenView.cpp
  group Application/gui/freda_screen
    ../../gui/src/freda_screen/: FREDAPresenter.cpp FREDAView.cpp
  group Application/gui/graphscreen_screen
    ../../gui/src/graphscreen_screen/: GraphScreenPresenter.cpp GraphScreenView.cpp
  group Application/gui/idlescreen_screen
    ../../gui/src/idlescreen_screen/: IdleScreenPresenter.cpp IdleScreenView.cpp
  group Application/gui/LFT
    ../../gui/src/LFT/: LFT.cpp LFT_Auto.cpp LFT_Information.cpp LFT_Logs.cpp LFT_Manual.cpp LFT_ProductionTests.cpp LFT_Settings.cpp
  group Application/gui/mainscreen_screen
    ../../gui/src/mainscreen_screen/: MainScreenPresenter.cpp MainScreenView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/powerlossrecoveryscreen_screen
    ../../gui/src/powerlossrecoveryscreen_screen/: PowerlossRecoveryScreenPresenter.cpp PowerlossRecoveryScreenView.cpp
  group Application/gui/processscreen_screen
    ../../gui/src/processscreen_screen/: ProcessScreenPresenter.cpp ProcessScreenView.cpp
  group Application/gui/settingsscreen_screen
    ../../gui/src/settingsscreen_screen/: SettingsScreenPresenter.cpp SettingsScreenView.cpp
  group Application/gui/touchtestscreen_screen
    ../../gui/src/touchtestscreen_screen/: TouchTestScreenPresenter.cpp TouchTestScreenView.cpp
  group Application/gui/usbmode_screen
    ../../gui/src/usbmode_screen/: UsbModePresenter.cpp UsbModeView.cpp
  group Application/main
    ../: main.cpp
  group Board/ETEM070001ZDH6
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/ETEM070001ZDH6/BSP
    ../bsp/source/bsp/: ETEM070001ZDH6TouchController.cpp STM32F7Instrumentation.cpp
  group Board/ETEM070001ZDH6/Vendor
    ../bsp/source/vendor/ETEM070001ZDH6/: etem070001zdh6.c etem070001zdh6_lcd.c etem070001zdh6_qspi.c etem070001zdh6_sdram.c etem070001zdh6_ts.c
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
